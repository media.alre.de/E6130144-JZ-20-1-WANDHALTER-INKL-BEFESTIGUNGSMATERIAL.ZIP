Properties of the parts of a building model (IFC4)

# File
Description: Wandhalter inkl. Befestigungsmaterial für Kanalhygrostat HI-1/HI-1F/HI-2, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: E6130144, Wandhalter inkl. Befestigungsmaterial für Kanalhygrostat HI-1/HI-1F/HI-2
In: Raum
Description: Wandhalter inkl. Befestigungsmaterial (Schrauben und Dübel) für Kanalhygrostat HI-1/HI-1F/HI-2.; Classification: EC001231 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: E6130144; ModelLabel: JZ-20-1; GlobalTradeItemNumber: 4050528031075; ProductURL: https://alre.de/produkt_E6130144
Pset_Specification - NominalLength: 0.062 m; NominalWidth: 0.052 m; NominalDepth: 0.018 m; NetWeight: 0.042
Pset_ALRE_ETIM_Properties - Ausführung: Montagehilfe; Länge: 62; ETIM-Klasse: EC001231; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-E6130144.pdf
